# Keil uVision project CarControl.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TM4C123G_Test
  c flags: Optim=6 OneElfS=1 v6LangP=3
  c define: PART_TM4C123GH6PM, ARDUINO
  c include: .\ExLib\Include;.\Hardware;.\Software
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group DeviceSupport
    ./ExLib/Source/DeviceSupport/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
    ./ExLib/Source/DeviceSupport/startup/: startup_rvmdk.S
  group ExLib
    ./ExLib/Source/: ExLib_Exception.cpp ExLib_EXTI.cpp ExLib_GPIO.cpp ExLib_Main.cpp ExLib_PrintStream.cpp ExLib_UART.cpp ExLib_Units.cpp Util_I2C.cpp Util_UART.cpp Util_GPIO.cpp ExLib_WriteStream.cpp ExLib_ReadStreamBuffered.cpp ExLib_ReadStream.cpp ExLib_BufferFIFO.cpp ExLib_HardwarePWM.cpp ExLib_PWM.cpp Util_HardwarePWM.cpp ExLib_System.cpp ExLib_I2C.cpp ExLib_QuadraticEncoder.cpp Util_QuadraticEncoder.cpp ExLib_Timer.cpp Util_Timer.cpp ExLib_ADC.cpp Util_ADC.cpp ExLib_FreeRTOS.cpp Util_FormattedPrint.cpp Util_SSI.cpp ExLib_SPI.cpp
  group User
    ./User/: main.cpp
  group FreeRTOS
    ./ExLib/Source/FreeRTOS/: croutine.c event_groups.c list.c port.c queue.c stream_buffer.c tasks.c timers.c heap_3.c
  group Hardware
    ./Hardware/: Motor.cpp Servo.cpp
  group Software
    ./Software/: PID.cpp
