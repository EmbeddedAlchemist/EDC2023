# Keil uVision project 555.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TM4C123G_Test
  c flags: Optim=6 OneElfS=1 v6LangP=3
  c define: PART_TM4C123GH6PM
  c include: .\ExLib\Include;.\Hardware;.\Software;.\u8g2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group DeviceSupport
    ./ExLib/Source/DeviceSupport/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
    ./ExLib/Source/DeviceSupport/startup/: startup_rvmdk.S
  group ExLib
    ./ExLib/Source/: ExLib_Exception.cpp ExLib_EXTI.cpp ExLib_GPIO.cpp ExLib_Main.cpp ExLib_PrintStream.cpp ExLib_UART.cpp ExLib_Units.cpp Util_I2C.cpp Util_UART.cpp Util_GPIO.cpp ExLib_WriteStream.cpp ExLib_ReadStreamBuffered.cpp ExLib_ReadStream.cpp ExLib_BufferFIFO.cpp ExLib_HardwarePWM.cpp ExLib_PWM.cpp Util_HardwarePWM.cpp ExLib_System.cpp ExLib_I2C.cpp ExLib_QuadraticEncoder.cpp Util_QuadraticEncoder.cpp ExLib_Timer.cpp Util_Timer.cpp ExLib_ADC.cpp Util_ADC.cpp ExLib_FreeRTOS.cpp Util_FormattedPrint.cpp Util_SSI.cpp ExLib_SPI.cpp
  group User
    ./User/: main.cpp
  group FreeRTOS
    ./ExLib/Source/FreeRTOS/: croutine.c event_groups.c list.c port.c queue.c stream_buffer.c tasks.c timers.c heap_3.c
  group Hardware
    ./Hardware/: Motor.cpp Servo.cpp
  group Software
    ./Software/: PID.cpp
  group U8g2
    ./u8g2/: u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_a2printer.c u8x8_d_gu800.c u8x8_d_hd44102.c u8x8_d_il3820_296x128.c u8x8_d_ist3020.c u8x8_d_ist7920.c u8x8_d_ks0108.c u8x8_d_lc7981.c u8x8_d_ld7032_60x32.c u8x8_d_ls013b7dh03.c u8x8_d_max7219.c u8x8_d_pcd8544_84x48.c u8x8_d_pcf8812.c u8x8_d_pcf8814_hx1230.c u8x8_d_s1d15e06.c u8x8_d_s1d15721.c u8x8_d_sbn1661.c u8x8_d_sed1330.c u8x8_d_sh1106_64x32.c u8x8_d_sh1106_72x40.c u8x8_d_sh1107.c u8x8_d_sh1108.c u8x8_d_sh1122.c u8x8_d_ssd1305.c u8x8_d_ssd1306_48x64.c u8x8_d_ssd1306_64x32.c u8x8_d_ssd1306_64x48.c u8x8_d_ssd1306_72x40.c u8x8_d_ssd1306_96x16.c u8x8_d_ssd1306_128x32.c u8x8_d_ssd1306_128x64_noname.c u8x8_d_ssd1306_2040x16.c u8x8_d_ssd1309.c u8x8_d_ssd1316.c u8x8_d_ssd1317.c u8x8_d_ssd1318.c u8x8_d_ssd1320.c u8x8_d_ssd1322.c u8x8_d_ssd1325.c u8x8_d_ssd1326.c u8x8_d_ssd1327.c u8x8_d_ssd1329.c u8x8_d_ssd1606_172x72.c u8x8_d_ssd1607_200x200.c u8x8_d_st7511.c u8x8_d_st7528.c u8x8_d_st7565.c u8x8_d_st7567.c u8x8_d_st7571.c u8x8_d_st7586s_erc240160.c u8x8_d_st7586s_s028hn118a.c u8x8_d_st7586s_ymc240160.c u8x8_d_st7588.c u8x8_d_st7920.c u8x8_d_st75160.c u8x8_d_st75256.c u8x8_d_st75320.c u8x8_d_stdio.c u8x8_d_t6963.c u8x8_d_uc1601.c u8x8_d_uc1604.c u8x8_d_uc1608.c u8x8_d_uc1609.c u8x8_d_uc1610.c u8x8_d_uc1611.c u8x8_d_uc1617.c u8x8_d_uc1638.c u8x8_d_uc1701_dogs102.c u8x8_d_uc1701_mini12864.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
